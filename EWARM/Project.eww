<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Appli\STM32N6570-DK_Appli.ewp</path>
  </project><project>
    <path>$WS_DIR$\FSBL\STM32N6570-DK_FSBL.ewp</path>
  </project>
  <batchBuild />
</workspace>
